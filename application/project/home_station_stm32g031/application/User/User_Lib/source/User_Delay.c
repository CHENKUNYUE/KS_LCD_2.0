//======================================================================
//======================================================================
//FileName:  User_Delay.c
//Author:
//Version: 1.0.0
//Date:
//Description:
//======================================================================

#include "User_Delay.h"

//======================================================================
//Function:	  Delay_ms()
//Description:	8MHZ
//======================================================================
void Delay_ms(uint16_t nms)
{
    uint8_t us, n_10us;
    
    while(nms--)
    {
        n_10us = 100;
        while(n_10us--)
        {
            us = 9;
            while(us--);
        }
    }
}

//======================================================================
//Function:	  Delay_10us()
//Description:	8MHZ
//======================================================================
void Delay_10us(uint8_t n_10us)
{
    uint8_t us;
    
    while(n_10us--)
    {
        us = 9;
        while(us--);
    }
}

//======================================================================
//Function:	  Delay_us()
//Description:	8MHZ
//======================================================================
void Delay_us(uint8_t n_us)
{
    while(n_us--);
}

//======================================================================
//ENDFILE
//======================================================================
